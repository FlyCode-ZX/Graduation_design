# Keil uVision project SOC_software.uvprojx, settings and files
target M3_software (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: SOC_software
  AfterMake: fromelf -cvf .\Objects\SOC_software.axf --vhx --32x1 -o image.hex
  AfterMake: fromelf -cvf .\Objects\SOC_software.axf -o image.txt
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\src
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ./src/: main.c CortexM3_driver.c handler.c Retarget.c system.c startup_CM3DS.s GPIO.c delay.c SmartCamera.c lcd.c misc.c
